# Keil uVision project newProject.uvprojx, settings and files
target Target 1 (5060750::V5.06 update 6 (build 750)::ARMCC)
  device: GD32F307VC GigaDevice
  pack: GigaDevice.GD32F30x_DFP.2.2.1
  cpu: IRAM(0x20000000,0x018000) IROM(0x08000000,0x040000) CPUTYPE("Cortex-M4") FPU2 CLOCK(12000000) ELITTLE
  output: newProject +hex
  c flags: Optim=1 OneElfS=1 uC99=1 uGnu=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\CMSIS\GD\GD32F30x\Include;.\CMSIS\GD\GD32F30x\Source;.\GD32F30x_standard_peripheral;.\GD32F30x_standard_peripheral\Include;.\GD32F30x_standard_peripheral\Source;.\user\inc;.\user\src
  memory RVCT4: ROM 0x8000000 size 0x40000
  memory RVCT9: RAM 0x20000000 size 0x18000
  group User
    ./user/src/: main.c
  group SPL
    ./GD32F30x_standard_peripheral/Source/: gd32f30x_adc.c gd32f30x_bkp.c gd32f30x_can.c gd32f30x_crc.c gd32f30x_ctc.c gd32f30x_dac.c gd32f30x_dbg.c gd32f30x_dma.c gd32f30x_enet.c gd32f30x_exmc.c gd32f30x_exti.c gd32f30x_fmc.c gd32f30x_fwdgt.c gd32f30x_gpio.c gd32f30x_i2c.c gd32f30x_misc.c gd32f30x_pmu.c gd32f30x_rcu.c gd32f30x_rtc.c gd32f30x_sdio.c gd32f30x_spi.c gd32f30x_timer.c gd32f30x_wwdgt.c gd32f30x_usart.c
    ./CMSIS/: gd32f30x_libopt.h
  group CMSIS
    ./CMSIS/GD/GD32F30x/Source/: system_gd32f30x.c
    ./CMSIS/GD/GD32F30x/Include/: gd32f30x.h
  group StartUp
    ./CMSIS/GD/GD32F30x/Source/ARM/: startup_gd32f30x_cl.s
software components: CMSIS:CORE 5.6.0, Device:GD32F30x_StdPeripherals:GPIO 2.2.0, Device:GD32F30x_StdPeripherals:RCU 2.2.0, Device:Startup 2.2.0
